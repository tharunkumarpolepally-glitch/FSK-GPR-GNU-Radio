options:
  parameters:
    generate_options: qt_gui
    id: fsk_gpr
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '128'
  states: {}
- name: delta_freq
  id: variable
  parameters:
    value: '1250000'
  states: {}
- name: fc
  id: variable
  parameters:
    value: '2400000000'
  states: {}
- name: num_delay
  id: variable
  parameters:
    value: '79'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '5000000'
  states: {}
- name: sim_samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: radar_estimator_fsk_0
  id: radar_estimator_fsk
  parameters:
    center_freq: fc
    delta_freq: delta_freq
    push_power: 'False'
  states: {}
- name: radar_signal_generator_fsk_c_0
  id: radar_signal_generator_fsk_c
  parameters:
    amplitude: '0.5'
    blocks_per_tag: '131072'
    freq_high: '625000'
    freq_low: '-625000'
    len_key: '"packet_len"'
    samp_per_freq: '1'
    samp_rate: samp_rate
  states: {}
- name: radar_usrp_echotimer_cc_0
  id: radar_usrp_echotimer_cc
  parameters:
    center_freq: fc
    channel_rx: '0'
    channel_tx: '0'
    num_delay_samps: num_delay
    samp_rate: samp_rate
  states: {}

connections:
- [radar_signal_generator_fsk_c_0, '0', radar_usrp_echotimer_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
